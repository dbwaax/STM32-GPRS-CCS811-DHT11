# Keil uVision project LED.uvprojx, settings and files
target LED (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\SYSTEM\DHT11;..\SYSTEM\esp8266\ESP8266_drive;..\SYSTEM\esp8266\STA_TCPClent_Test;..\SYSTEM\convert;..\SYSTEM\adc;..\SYSTEM\total;..\SYSTEM\oled\NVIC;..\SYSTEM\oled\OLED;..\SYSTEM\oled\IIC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c system.c
    ../SYSTEM/DHT11/: DHT11.c
    ../SYSTEM/esp8266/ESP8266_drive/: esp8266_drive.c
    ../SYSTEM/esp8266/STA_TCPClent_Test/: sta_tcpclent_test.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/convert/: Str2float.c
    ../SYSTEM/adc/: adc.c
    ../SYSTEM/total/: DataCollection.c
    ../SYSTEM/oled/IIC/: IIC.c
    ../SYSTEM/oled/NVIC/: NVIC.c
    ../SYSTEM/oled/OLED/: OLED.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_tim.c
  group README
    ../: README.TXT
